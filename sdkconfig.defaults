## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_XPT2046_INTERRUPT_MODE=y
CONFIG_XPT2046_CONVERT_ADC_TO_COORDS=n
```
